# Keil uVision project sample.uvprojx, settings and files
target sample (6240000::V6.24::ARMCLANG)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: sample +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_NUCLEO_64,USE_HAL_DRIVER,STM32F446xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/BSP/STM32F4xx-Nucleo;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f446xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c dlsm_app.c
  group Drivers/BSP/STM32F4xx_Nucleo
    ../Drivers/BSP/STM32F4xx-Nucleo/: stm32f4xx_nucleo.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group dlms
    ../dlms/src/: apdu.c asn1Parser.c bigInteger.c bitarray.c bytebuffer.c ciphering.c client.c converters.c cosem.c curve.c datainfo.c date.c dlms.c dlmsSettings.c eccPoint.c gx509Certificate.c gxaes.c gxarray.c gxecdsa.c gxget.c gxinvoke.c gxkey.c gxmd5.c gxobjects.c gxPkcs10.c gxserializer.c gxset.c gxsetignoremalloc.c gxsetmalloc.c gxsha1.c gxsha256.c gxsha384.c gxvalueeventargs.c helpers.c message.c notify.c objectarray.c parameters.c privateKey.c publicKey.c replydata.c server.c serverevents.c shamirs.c variant.c
software components: CMSIS:CORE 6.2.0
